# Keil uVision project ucosii.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ucosii
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Cfg;.\Source;.\Tools;.\Ports;.\SEGGER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Ports
    ./Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group Cfg
    ./Cfg/: app_cfg.h app_hooks.c os_cfg.h
  group Source
    ./Source/: os.h os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_trace.h ucos_ii.h
  group Tools
    ./Tools/: HM-10.c HM-10.h i2c.c i2c.h LED.c LED.h MPU6050.c MPU6050.h Nvic.c Nvic.h OLED.c OLED.h OLED_Font.h OLED_Font2.h oled2.c oled2.h PWM.c PWM.h PWMIN.c PWMIN.h systick.c systick.h USART.c USART.h main.c includes.h main.h
  group SEGGER
    ./SEGGER/: Global.h SEGGER.h SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_SYSVIEW.c SEGGER_SYSVIEW.h SEGGER_SYSVIEW_Conf.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_Int.h SEGGER_SYSVIEW_uCOSII.c SEGGER_SYSVIEW_Config_uCOSII.c os_trace_events.h os_cfg_trace.h
software components: CMSIS:CORE 5.0.1, Device:Startup 2.6.2
